options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: no_gui
    id: lora_TX
    output_language: python
  states: {}

blocks:
- name: TX_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9000000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /usr/src/OWLSDR/testcapture
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello UtD! This is the UtD HackRF One @*13")
    period: frame_period
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {state: disabled}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: '":"'
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    time_source0: gpsdo
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.5"'
    gain0: TX_gain
    len_tag_name: frame_len
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_throttle_0, '0', lora_sdr_whitening_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', osmosdr_sink_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0, set_msg]
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
